# Keil uVision project stm32.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_protect +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\USER;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\CM3\CoreSupport;..\system\datatype;..\APP\Gripper_Valve;..\Driver\ChipDriver\NVIC;..\Driver\ChipDriver\pwm;..\Driver\ChipDriver\SysTick;..\Driver\ChipDriver\timer;..\Driver\PeriphDriver\EXTI;..\Driver\PeriphDriver\GPIO;..\Driver\PeriphDriver\LED;..\Driver\ChipDriver\usart;..\system\delay;..\Driver\ChipDriver\ADC;..\Driver\ChipDriver\IIC;..\Driver\PeriphDriver\ATC02;..\APP\comm_timer_function;..\APP\Calculate_val;..\Driver\ChipDriver\comm;..\Driver\ChipDriver\DMA;..\Driver\ChipDriver\modbus;..\system\sys;..\Driver\PeriphDriver\Iflash;..\Driver\PeriphDriver\MLX90614
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../USER/: main.c stm32f10x_it.c PID.C timerApi.c can.c
    ../system/delay/: delay.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group App
    ../APP/comm_timer_function/: CommTimerFunction.c
    ../APP/Calculate_val/: Calculate_val.c
  group ChipDriver
    ../Driver/ChipDriver/NVIC/: NVIC.C
    ../Driver/ChipDriver/pwm/: pwm.c
    ../Driver/ChipDriver/SysTick/: SysTick.c
    ../Driver/ChipDriver/ADC/: ADC.C
    ../Driver/ChipDriver/DMA/: DMA.c
    ../Driver/ChipDriver/usart/: usart1.c usart2.c
    ../Driver/PeriphDriver/Iflash/: DataFlash.c
    ../Driver/PeriphDriver/MLX90614/: smbus.c smbus.h
    ../Driver/ChipDriver/timer/: timer.c
  group PeriphDriver
    ../Driver/PeriphDriver/GPIO/: GPIO.C
    ../Driver/PeriphDriver/LED/: led.c
  group modbus
    ../Driver/ChipDriver/comm/: comm.c
    ../Driver/ChipDriver/modbus/: cmd03.c cmd06.c cmd16.c modbus.c StructUsartBuf.c CRC.C
