# IAR project feeder.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.CCIncludePath2: ..; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\USER\; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; ..\Libraries\CMSIS\CM3\; $PROJ_DIR; ..\system\datatype\; ..\system\sys\; ..\system\delay\; ..\Driver\ChipDriver\pwm; ..\Driver\PeriphDriver\PinInputOutput; ..\Driver\PeriphDriver\GPIO; ..\Driver\ChipDriver\NVIC; ..\Driver\PeriphDriver\EXTI; ..\Driver\PeriphDriver\LED; ..\Driver\ChipDriver\timer; ..\APP\Gripper_Valve; ..\Driver\ChipDriver\SysTick
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: feeder.srec
  ILINK.IlinkOutputFile: feeder.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../APP/Gripper_Valve/: Gripper_Valve.c
  group Driver/ChipDriver
    ../Driver/ChipDriver/NVIC/: NVIC.C
    ../Driver/ChipDriver/pwm/: pwm.c
    ../Driver/ChipDriver/SysTick/: SysTick.c
    ../Driver/ChipDriver/timer/: timer.c
  group Driver/PeriphDriver
    ../Driver/PeriphDriver/EXTI/: exti.c
    ../Driver/PeriphDriver/GPIO/: GPIO.C
    ../Driver/PeriphDriver/LED/: led.c
  group lib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group smsis
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
  group user
    ../USER/: main.c stm32f10x_it.c
